FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

